# IAR project GeneralControlPlatform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1752 NXP LPC1752
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../SysCore/Core; ../SysCore/Drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GeneralControlPlatform.bin
  ILINK.IlinkOutputFile: GeneralControlPlatform.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ALG
    ../ALG/: crc16.c crc8.c
  group Application
    ../Application/: GC_CtrlIOTable.c GC_CtrlIOTable.h GC_HardwareDef.h GC_HwCtrl.c GC_HwCtrl.h GC_LockCtrl.c GC_LockCtrl.h GC_MainProc.c GC_MainProc.h GC_SysCtrl.c GC_SysCtrl.h GC_SysParmMan.c GC_SysParmMan.h
  group CMU
    ../CMU/: CMU_DataStructDef.h CMU_ErrorCodeDef.h CMU_Interface.h CMU_PubFun.c UIN_GlobalDataDef.h
  group CMU/AbstractionLayer
    ../CMU/AbstractionLayer/: AbstractionLayer.c AbstractionLayer.h
  group CMU/ProtocolLayer
    ../CMU/ProtocolLayer/: CMU_CmdProcess.c CMU_CmdProcess.h CMU_ErrorMana.c CMU_ErrorMana.h CMU_ExApi.c CMU_ExApi.h CMU_PeriodDataMana.c CMU_PeriodDataMana.h CMU_RcvDataProcess.c CMU_RcvDataProcess.h CMU_SendDataProcess.c CMU_SendDataProcess.h ComDataStructDef.h
  group DataType
    ../DataType/: DataType.h
  group Main
    ../Main/: Main.c
  group PeriDrivers/Eeprom
    ../PeriDrivers/Eeprom/: at24cxx.c at24cxx.h Eeprom.c Eeprom.h
  group PeriDrivers/NixieTube
    ../PeriDrivers/NixieTube/: NixieTube.c NixieTube.h TM1617.c TM1617.h
  group SysCore/Core
    ../SysCore/Core/: arm_common_tables.h arm_math.h cmsis_175x_6x.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h error.h hw_types.h lpc_types.h sys_config.h
  group SysCore/Drivers
    ../SysCore/Drivers/: adc_17xx_40xx.c adc_17xx_40xx.h can_17xx_40xx.c can_17xx_40xx.h chip.h chip_17xx_40xx.c chip_lpc175x_6x.h chip_lpc177x_8x.h clock_17xx_40xx.c clock_17xx_40xx.h cmp_17xx_40xx.c cmp_17xx_40xx.h cmsis.h crc_17xx_40xx.c crc_17xx_40xx.h dac_17xx_40xx.c dac_17xx_40xx.h eeprom_17xx_40xx.c eeprom_17xx_40xx.h emc_17xx_40xx.c emc_17xx_40xx.h enet_17xx_40xx.c enet_17xx_40xx.h fmc_17xx_40xx.h fpu_init.c fpu_init.h gpdma_17xx_40xx.c gpdma_17xx_40xx.h gpio_17xx_40xx.c gpio_17xx_40xx.h gpioint_17xx_40xx.c gpioint_17xx_40xx.h i2c_17xx_40xx.c i2c_17xx_40xx.h i2s_17xx_40xx.c i2s_17xx_40xx.h iap.c iap.h iocon_17xx_40xx.c iocon_17xx_40xx.h lcd_17xx_40xx.c lcd_17xx_40xx.h mcpwm_17xx_40xx.h pmu_17xx_40xx.c pmu_17xx_40xx.h qei_17xx_40xx.h ring_buffer.c ring_buffer.h ritimer_17xx_40xx.c ritimer_17xx_40xx.h romapi_17xx_40xx.h rtc_17xx_40xx.c rtc_17xx_40xx.h sdc_17xx_40xx.c sdc_17xx_40xx.h sdmmc_17xx_40xx.c sdmmc_17xx_40xx.h spi_17xx_40xx.c spi_17xx_40xx.h spifi_17xx_40xx.h ssp_17xx_40xx.c ssp_17xx_40xx.h sysctl_17xx_40xx.c sysctl_17xx_40xx.h sysinit_17xx_40xx.c timer_17xx_40xx.c timer_17xx_40xx.h uart_17xx_40xx.c uart_17xx_40xx.h usb_17xx_40xx.h wwdt_17xx_40xx.c wwdt_17xx_40xx.h
  group SysCore/Startup
    ../SysCore/Startup/: startup_LPC17xx.s sysinit.c
  group SysInit
    ../SysInit/: SYS_Init.c SYS_Init.h
  group SysPeripheral
    ../SysPeripheral/: Demo.c Demo.h
  group SysPeripheral/CAN
    ../SysPeripheral/CAN/: CAN.c CAN.h CanDataStructDef.h CanInterface.h
  group SysPeripheral/Enet
    ../SysPeripheral/Enet/: EnetDataStructDef.h EnetInterface.h
  group SysPeripheral/GPIO
    ../SysPeripheral/GPIO/: GPIO_Man.c GPIO_Man.h
  group SysPeripheral/HAL
    ../SysPeripheral/HAL/: HAL_Can.c HAL_Can.h HAL_Flash.c HAL_Flash.h HAL_Gpio.c HAL_Gpio.h HAL_IRQHandler.c HAL_IRQHandler.h HAL_SysCtrl.c HAL_SysCtrl.h HAL_SysInit.c HAL_SysInit.h HAL_SysTick.c HAL_SysTick.h HAL_TimeDelay.c HAL_TimeDelay.h HAL_Uart.c HAL_Uart.h HAL_Watchdog.c HAL_Watchdog.h ReadMe.txt
  group SysPeripheral/I2C
    ../SysPeripheral/I2C/: I2C_BaseOps.c I2C_DataStructDef.h I2C_DeviceAPI.c I2C_DeviceOps.c I2C_Interface.h
  group SysPeripheral/IRQ
    ../SysPeripheral/IRQ/: IRQ_Man.c IRQ_Man.h
  group SysPeripheral/KEY
    ../SysPeripheral/KEY/: KEY.c KEY.h
  group SysPeripheral/SysCtrl
    ../SysPeripheral/SysCtrl/: SysCtrl.c SysCtrl.h
  group SysPeripheral/SysTick
    ../SysPeripheral/SysTick/: SysTick.c SysTick.h SysTimer.c SysTimer.h
  group SysPeripheral/UART
    ../SysPeripheral/UART/: UART.c UART.h UartDataStructDef.h UartInterface.c UartInterface.h ucom.c ucom.h
  group Version
    ../Version/: VER_DataStructDef.h Version.h
